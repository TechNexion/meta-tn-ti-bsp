FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

#COMPATIBLE_MACHINE:append = "|rovy-4vm"
TARGET_PRODUCT:rovy-4vm = "j721e_linux"