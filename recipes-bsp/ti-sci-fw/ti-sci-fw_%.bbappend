SYSFW_PREFIX_axon-am62xx-k3r5-gp = "fs"
SYSFW_PREFIX_axon-am62xx-k3r5-hs-se = "fs"
SYSFW_PREFIX_axon-am62xx-k3r5-hs-fs = "fs"
