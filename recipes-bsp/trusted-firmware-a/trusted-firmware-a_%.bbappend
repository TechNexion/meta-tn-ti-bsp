do_compile_append_axon-am62xx() {
        tfa_sign_k3hs
}

do_compile_append_axon-am62ax() {
        tfa_sign_k3hs
}
