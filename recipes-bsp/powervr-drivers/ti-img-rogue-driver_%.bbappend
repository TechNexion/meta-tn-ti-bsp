FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

TARGET_PRODUCT:rovy-4vm = "j721e_linux"