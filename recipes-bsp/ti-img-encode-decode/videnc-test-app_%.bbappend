COMPATIBLE_MACHINE_append = "|rovy-4vm"
