COMPATIBLE_MACHINE_append = "|axon-am62ax"

PLAT_SOC_axon-am62ax = "am62a"
