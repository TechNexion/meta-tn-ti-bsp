PLAT_SOC_axon-am62ax = "am62a"

COMPATIBLE_MACHINE_append = "|axon-am62ax"

TIDL_SOC_NAME_axon-am62ax = "AM62A"
