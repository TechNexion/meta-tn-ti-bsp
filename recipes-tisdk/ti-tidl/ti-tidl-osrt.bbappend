PLAT_SOC_axon-am62ax = "am62a"

COMPATIBLE_MACHINE_append = "|axon-am62ax"
