COMPATIBLE_MACHINE_append = "|axon-am62ax"
