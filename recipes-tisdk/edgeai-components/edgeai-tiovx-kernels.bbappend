include recipes-bsp/tn-machine-add/tn-machine-add.inc