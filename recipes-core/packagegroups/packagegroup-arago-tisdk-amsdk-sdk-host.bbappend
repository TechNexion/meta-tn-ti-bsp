EXTRA_FILES_append_rovy-4vm = " edgeai-uenv"
