GRAPHICS_DEMO_axon-am62xx = "\
    hmi-demo \
    powervr-graphics \
    camera-demo \
"
