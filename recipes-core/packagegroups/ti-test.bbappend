# Do not add PRU tools to image
TI_TEST_TI_TOOLS:remove:rovy-4vm = " pru-icss"