DL_PACKAGES_axon-am62xx = " \
    neo-ai-dlr \
    onnxruntime \
    onnxruntime-dev \
"

PYTHON_PACKAGES_axon-am62xx = " \
    python3-tensorflow-lite \
"
