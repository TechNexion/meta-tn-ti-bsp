# Do not add PRU tools to image
UTILS:remove:rovy-4vm = " pru-icss"