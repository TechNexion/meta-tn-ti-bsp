# Do not add PRU tools to image
EXTRA_TI_TOOLS:remove:rovy-4vm = " nativesdk-ti-cgt-pru"
