SYSTEMD_AUTO_ENABLE_${PN}_axon-am62xx = "disable"
