DEPLOY_IMAGES_NAME_append_axon-am62xx = " ti-fs-firmware-am62x-hs-fs-enc.bin ti-fs-firmware-am62x-hs-fs-cert.bin tiboot3-am62x-hs-evm.bin tiboot3-am62x-gp-evm.bin ti-fs-firmware-am62x-hs-enc.bin ti-fs-firmware-am62x-hs-cert.bin ti-fs-firmware-am62x-gp.bin ipc_echo_testb_mcu1_0_release_strip.xer5f"
DEPLOY_IMAGES_NAME_append_axon-am62ax = " ipc_echo_testb_mcu1_0_release_strip.xer5f tiboot3-am62ax-gp-evm.bin tiboot3-am62ax-hs-evm.bin tiboot3-am62ax-hs-fs-evm.bin ti-fs-firmware-am62ax-gp.bin ti-fs-firmware-am62ax-hs-cert.bin ti-fs-firmware-am62ax-hs-enc.bin ti-fs-firmware-am62ax-hs-fs-cert.bin ti-fs-firmware-am62ax-hs-fs-enc.bin fitImage-its.its"

TARGET_IMAGES_append_axon-am62ax = " tisdk-docker-rootfs-image tisdk-tiny-image tisdk-edgeai-image"
